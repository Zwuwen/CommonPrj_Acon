# Keil uVision project STM32 Prj.uvproj, settings and files
target CommonPrj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32 Prj +hex
  AfterMake: fromelf.exe --bin -o "NewRobust.bin"  "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\USER\AIA_Lib\Inc;.\USER\Peripheral;.\USER\Driver;.\USER\Core;.\USER\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Task
    ./USER/Task/: main.c DemoTask.c TemperatureTask.c StepperMotor.c StepperMotorTask.c StepperMotorInit.c
  group Core
    ./USER/Core/: stm32f10x_it.c
  group Peripheral
    ./USER/Peripheral/: AD7708_SPI.c
  group Driver
    ./USER/Driver/: CAN_Driver.c IIC_Driver.c ADC_Driver.c GPIO_Driver.c DAC_Driver.c Flash_Driver.c PWM_Driver.c
  group AIA_Lib
    ./USER/AIA_Lib/: AIA_Bootload.c AIA_PID.c AIA_Protocol2.0.c AIA_SyncData.c AIA_Utilities.c AIA_ModuleCore.c AIA_Persistence.c AIA_CmdFIFO.c
    ./USER/AIA_Lib/Inc/: AIA_ErrorCode.h
  group STM32_LIB
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_dac.c stm32f10x_spi.c
  group MDK_STARTUP
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./USER/Core/: system_stm32f10x.c
